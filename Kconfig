## Kconfig
```kconfig
config RTL8188EU
	tristate "Realtek 8188EU USB WiFi"
	depends on USB
    select WIRELESS_EXT
    select WEXT_PRIV
	---help---
	  RTL8188EU usb WiFi linux driver
```
